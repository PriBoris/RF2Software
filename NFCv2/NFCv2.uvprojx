# Keil uVision project NFCv2.uvprojx, settings and files
target NFCv2 MCU (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NFCv2 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group main
    ./src/: main.cpp Ports.cpp Ports.h Clock.cpp Clock.h MFRC522.cpp MFRC522.h Indicator.cpp Indicator.h
software components: CMSIS:CORE 5.0.0, Device:Startup 2.2.3
