# Keil uVision project RtcuV2.uvproj, settings and files
target Target RTCUv2 (ARM-ADS)
  device: STM32F427VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: RtcuV2 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\Source;.\Source\STM32F4xx_StdPeriph_Driver\inc;.\Source\STM32F4xx;..\CommonSrc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./Source/: startup_stm32f427x.s main.cpp stm32f4xx_conf.h system_stm32f4xx.c
    ../Library/STM32F4xx/: stm32f4xx.h system_stm32f4xx.h
  group system
    ./Source/system/: heartbeat.cpp heartbeat.h ports.cpp ports.h
  group servo
    ./Source/servo/: servo.cpp servo.h encoder.cpp encoder.h StrainGauge.cpp StrainGauge.h Fieldbus.cpp Fieldbus.h USS.cpp USS.h
  group actuators
    ./Source/actuators/: feedback.cpp actuators.h actuators.cpp
  group hmi
    ./Source/hmi/: hmi.cpp hmi.h diagnostics.cpp diagnostics.h RxMessageQueue.cpp RxMessageQueue.h
  group nfc
    ./Source/nfc/: nfc.cpp nfc.h
  group nv
    ./Source/nv/: rtc.cpp bkpsram.cpp eeprom.cpp rtc.h bkpsram.h eeprom.h
  group business
    ./Source/business/: settings.cpp settings.h MainTick.cpp MainTick.h Odometer.cpp Odometer.h ReportCurrentMode.cpp Errors.cpp Errors.h EmergencyStop.cpp EmergencyStop.h MachineSettings.h MachineSettings.cpp ExcerciseSettings.cpp ExcerciseSettings.h PersonalSettings.cpp PersonalSettings.h RangeAdjustment.cpp RangeAdjustment.h SetSubmode.cpp Parking.cpp Parking.h ForceTestDynamic.cpp ForceTestDynamic.h PositionTask.cpp PositionTask.h ForceTestStatic.cpp ForceTestStatic.h Excercise.cpp Excercise.h ReportServoMode.cpp
  group StdPeriphDriver
    ./Source/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_usart.c misc.c stm32f4xx_syscfg.c stm32f4xx_pwr.c
  group CommonSrc
    ../CommonSrc/: crc32.cpp crc32.h protocol.cpp protocol.h
