# Keil uVision project RtcuV1Initialization.uvproj, settings and files
target RTCUv1 INIT (ARM-ADS)
  device: STM32F205VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: RtcuV1Initialization
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\STM32F2xx_StdPeriph_Driver\inc;.\Source;..\STM32F2xx
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main
    ./Source/: gpio.cpp RtcNvmem.cpp RtcNvmem.h RtcuV1Initialization.cpp RtcuV1Initialization.h
  group STM32F2_StdPrephDriver
    ../STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group STM32F2
    ../STM32F2xx/: startup_stm32f2xx.s stm32f2xx.h stm32f2xx_conf.h system_stm32f2xx.c system_stm32f2xx.h
